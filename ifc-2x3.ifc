Properties of the parts of a building model (IFC2X3)

# File
Description: Funk-Heizungsaktor für Heizkörperventile, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G8000422, Funk-Heizungsaktor für Heizkörperventile
In: Raum
Description: Funkaktoren (Funk-Heizungsregler), die in Verbindung mit alre-Funk-Raumtemperatursensoren eine Einzelraum-Temperaturregelung verwirklichen. Anwendung überwiegend im Sanierungsbereich oder bei Heizungsanlagenerweiterungen. 1-Kanal Funk-Temperaturaktor für Heizkörperventile. Adapter für Danfoss RA, RAV, RAVL im Lieferumfang enthalten.; Classification: EC000436 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G8000422; ModelLabel: HTFMA-180.161; GlobalTradeItemNumber: 4050528065612; ProductURL: https://alre.de/produkt_G8000422
Pset_Specification - NominalLength: 0.075 m; NominalWidth: 0.064 m; NominalDepth: 0.048 m; NetWeight: 0.19
Pset_ALRE_ETIM_Properties - Montageart: sonstige; Farbe: weiß; Stromversorgung: Batterie; Werkstoffgüte: Thermoplast; Werkstoff: Kunststoff; RAL-Nummer (ähnlich): 9010; Ausführung der Oberfläche: matt; Geeignet für Schutzart (IP): IP30; Schutzart (NEMA): sonstige; ETIM-Klasse: EC000436; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G8000422.pdf
